// ═══════════════════════════════════════════════════════════════════════════════
//  keymap_core.dtsi -- ONE keymap, shared by all seven keyboards:
//  klor / konrad / saegewerk / corne / draculad / totem / sweep.
//
//  Nothing in this file knows what board it is on. Every key position number
//  lives in layout_<board>.dtsi, generated from that board's matrix_transform.
//  This file only ever refers to positions by name (POS_*, KEYS_L, KEYS_R).
//
//  Canonical grid -- 36 keys every board has, plus 10 optional slots:
//
//      o1l  l1  l2  l3  l4  l5              r1  r2  r3  r4  r5   o1r
//      o2l  l6  l7  l8  l9 l10              r6  r7  r8  r9 r10   o2r
//      o3l l11 l12 l13 l14 l15  midl midr  r11 r12 r13 r14 r15   o3r
//                  lt1 lt2 lt3  t4l   t4r  rt1 rt2 rt3
//
//  Which optional slots each board has:
//      klor/konrad (44)  o2*  o3*  mid*  t4*
//      corne       (42)  o1*  o2*  o3*
//      totem       (38)       o3*
//      dracu       (38)            mid*
//      saegewerk   (36)  -- mirrored, see layout_saegewerk.dtsi
//      sweep       (34)
//  A board's LAYOUT() silently drops the slots it lacks, so this file can
//  always specify all 46.
//
//  Feature flags a board may define: HAS_ENCODER, HAS_TWO_ENCODERS,
//  HAS_OUTER_R3, HAS_GAMING, HAS_QWERTY, IS_MAC, MIRRORED
// ═══════════════════════════════════════════════════════════════════════════════

#include <behaviors.dtsi>
#include <dt-bindings/zmk/bt.h>
#include <dt-bindings/zmk/keys.h>
#include <dt-bindings/zmk/behaviors.h>
#include <dt-bindings/zmk/outputs.h>

#define BASE   0
#define LOWER  1
#define RAISE  2
#define NAV    3
#define SYS    4
#define GAMING 5

// QWERTY sits after gaming when a board has both, and takes gaming's place
// when it doesn't -- ZMK numbers layers by the order they appear, with no
// gaps, so the number has to follow whichever optional layers came before.
#ifdef HAS_GAMING
  #define QWERTY 6
#else
  #define QWERTY 5
#endif

#define ___ &trans
#define XXX &none

#define slashP     &th LS(SLASH) P
#define HYPEReturn &tb LS(LC(LA(LGUI))) RETURN
#define MehSpace   &tb LS(LC(LALT)) SPACE

// Boards with an outer row-3 key put COMMA there, so the middle of row 3 can be
// a plain period. Boards without it need both on one key, hence the morph.
#ifdef HAS_OUTER_R3
  #define KEY_DOT &kp PERIOD
#else
  #define KEY_DOT &comma_morph
#endif

// Copy, paste and zoom are Command on a Mac and Ctrl everywhere else. The
// totem is the Mac keyboard; the rest are used on Linux and Windows. Note
// that switching tabs stays Ctrl on every platform, so it does not use this.
#ifdef IS_MAC
  #define CMD(key) LG(key)
#else
  #define CMD(key) LC(key)
#endif

// Delete the word to the left. A Mac wants Option+Backspace for this;
// Ctrl+Backspace does nothing there. Everywhere else it is Ctrl+Backspace.
// Holds the whole binding, not just the keycode, because that is what every
// other shorthand here does and what keymap-forge expects to be able to edit.
#ifdef IS_MAC
  #define DEL_WORD &kp LA(BACKSPACE)
#else
  #define DEL_WORD &kp LC(BACKSPACE)
#endif

// What the knobs do. A board with two gets volume on one and page up/down on
// the other; which knob is which depends on whether the board is mirrored,
// because on a mirrored board the half the firmware calls "left" is the half
// your right hand is on. Boards with one knob get volume.
#ifdef HAS_TWO_ENCODERS
  #ifdef MIRRORED
    #define ENCODERS sensor-bindings = <&inc_dec_kp PG_UP PG_DN &inc_dec_kp C_VOL_UP C_VOL_DN>;
  #else
    #define ENCODERS sensor-bindings = <&inc_dec_kp C_VOL_UP C_VOL_DN &inc_dec_kp PG_UP PG_DN>;
  #endif
#elif defined(HAS_ENCODER)
  #define ENCODERS sensor-bindings = <&inc_dec_kp C_VOL_UP C_VOL_DN>;
#else
  #define ENCODERS
#endif

// The outer row-3 key toggles whichever alternate layer this board has. Only
// reference a layer on boards that actually define it -- naming a layer that
// isn't there will not compile.
#ifdef HAS_GAMING
  #define KEY_GAME &tog GAMING
#elif defined(HAS_QWERTY)
  #define KEY_GAME &tog QWERTY
#else
  #define KEY_GAME ___
#endif

// Leave the keys listening while the rest of the keyboard sleeps, so pressing
// one starts it up again. A keyboard without this can only be revived by
// plugging it in: it powers the key grid down along with everything else, and
// nothing is left to notice you typing. Costs nothing while no key is held.
//
// This is a fact about the hardware rather than the keymap, and it belongs
// here anyway: every board names its key grid kscan0, and this file is the one
// thing all seven are given. Kept per board, it gets forgotten -- the konrad
// went a month needing a cable every morning because it was (2026-08-14). The
// draculad and totem also set it in their own shield files, harmlessly: it is
// the same value written twice.
&kscan0 {
    wakeup-source;
};

/ {
    combos {
        compatible = "zmk,combos";

        // Symbol combos -- base layer only. On LOWER these positions are
        // digits; without the layers property, typing "123" fires
        // ctrl_backspace.
        combo_enter       { timeout-ms = <40>; bindings = <&kp RETURN>;            key-positions = <POS_R7 POS_R8 POS_R9>;   layers = <BASE>; require-prior-idle-ms = <150>; };
        combo_colon       { timeout-ms = <40>; bindings = <&kp SEMI>;              key-positions = <POS_R9 POS_R10>;         layers = <BASE>; require-prior-idle-ms = <150>; };
        combo_angle       { timeout-ms = <40>; bindings = <&angle_morph>;          key-positions = <POS_R7 POS_R9>;          layers = <BASE>; require-prior-idle-ms = <150>; };
        left_bracket      { timeout-ms = <40>; bindings = <&kp LEFT_BRACKET>;      key-positions = <POS_R7 POS_R8>;          layers = <BASE>; require-prior-idle-ms = <150>; };
        right_bracket     { timeout-ms = <40>; bindings = <&kp RIGHT_BRACKET>;     key-positions = <POS_R8 POS_R9>;          layers = <BASE>; require-prior-idle-ms = <150>; };
        left_parenthesis  { timeout-ms = <40>; bindings = <&kp LEFT_PARENTHESIS>;  key-positions = <POS_R2 POS_R3>;          layers = <BASE>; require-prior-idle-ms = <150>; };
        right_parenthesis { timeout-ms = <40>; bindings = <&kp RIGHT_PARENTHESIS>; key-positions = <POS_R3 POS_R4>;          layers = <BASE>; require-prior-idle-ms = <150>; };
        left_brace        { timeout-ms = <40>; bindings = <&kp LEFT_BRACE>;        key-positions = <POS_R12 POS_R13>;        layers = <BASE>; require-prior-idle-ms = <150>; };
        right_brace       { timeout-ms = <40>; bindings = <&kp RIGHT_BRACE>;       key-positions = <POS_R13 POS_R14>;        layers = <BASE>; require-prior-idle-ms = <150>; };

        // Editing combos -- wanted everywhere except GAMING.
        ctrl_backspace    { timeout-ms = <40>; bindings = <DEL_WORD>;              key-positions = <POS_R12 POS_R13 POS_R14>; layers = <BASE RAISE NAV>; };
        combo_escape      { timeout-ms = <40>; bindings = <&kp ESCAPE>;            key-positions = <POS_L2 POS_L3>;           layers = <BASE LOWER RAISE NAV>; };
        combo_tab         { timeout-ms = <40>; bindings = <&kp TAB>;               key-positions = <POS_L3 POS_L4>;           layers = <BASE LOWER RAISE NAV>; };
        // Cut, copy and paste on the left hand, so they still work with the
        // mouse in your right. Base layer only: these keys are symbols on
        // LOWER and RAISE, and Z X C on GAMING, where pressing two together is
        // just playing. CMD() so the totem gets Command and the rest Ctrl.
        combo_cut         { timeout-ms = <40>; bindings = <&kp CMD(X)>;            key-positions = <POS_L12 POS_L13>;         layers = <BASE>; };
        combo_copy        { timeout-ms = <40>; bindings = <&kp CMD(C)>;            key-positions = <POS_L13 POS_L14>;         layers = <BASE>; };
        combo_paste       { timeout-ms = <40>; bindings = <&kp CMD(V)>;            key-positions = <POS_L14 POS_L15>;         layers = <BASE>; };
    };

    behaviors {
        // KEYS_R / KEYS_L come from the board's transform, so these can never
        // drift out of sync with the physical layout the way a hand-copied
        // position list does.
        HML: HML {
            compatible = "zmk,behavior-hold-tap";
            display-name = "HML";
            #binding-cells = <2>;
            bindings = <&kp>, <&kp>;
            tapping-term-ms = <280>;
            quick-tap-ms = <175>;
            require-prior-idle-ms = <150>;
            flavor = "balanced";
            hold-trigger-on-release;
            hold-trigger-key-positions = <KEYS_R>;
        };

        HMR: HMR {
            compatible = "zmk,behavior-hold-tap";
            display-name = "HMR";
            #binding-cells = <2>;
            bindings = <&kp>, <&kp>;
            tapping-term-ms = <280>;
            quick-tap-ms = <175>;
            require-prior-idle-ms = <150>;
            flavor = "balanced";
            hold-trigger-on-release;
            hold-trigger-key-positions = <KEYS_L>;
        };

        th: th {
            compatible = "zmk,behavior-hold-tap";
            display-name = "Taphold";
            #binding-cells = <2>;
            bindings = <&kp>, <&kp>;
            tapping-term-ms = <280>;
            quick-tap-ms = <175>;
            require-prior-idle-ms = <150>;
            flavor = "tap-preferred";
        };

        tb: tb {
            compatible = "zmk,behavior-hold-tap";
            display-name = "Thumb hold";
            #binding-cells = <2>;
            bindings = <&kp>, <&kp>;
            tapping-term-ms = <280>;
            quick-tap-ms = <175>;
            flavor = "tap-preferred";
        };

        angle_morph: angle_morph {
            compatible = "zmk,behavior-mod-morph";
            #binding-cells = <0>;
            bindings = <&kp LT>, <&kp GT>;
            mods = <(MOD_LSFT | MOD_RSFT)>;
        };

        comma_morph: comma_morph {
            compatible = "zmk,behavior-mod-morph";
            #binding-cells = <0>;
            bindings = <&kp COMMA>, <&kp DOT>;
            mods = <(MOD_LSFT | MOD_RSFT)>;
        };

        ltl: ltl {
            compatible = "zmk,behavior-hold-tap";
            display-name = "LTL";
            #binding-cells = <2>;
            bindings = <&mo>, <&kp>;
            tapping-term-ms = <200>;
            quick-tap-ms = <175>;
            flavor = "balanced";
        };

#ifdef HAS_GAMING
        GamRT: GamRT { compatible = "zmk,behavior-mod-morph"; #binding-cells = <0>;
                       bindings = <&kp R>, <&kp T>; mods = <(MOD_LSFT | MOD_RSFT)>; };
        GamFG: GamFG { compatible = "zmk,behavior-mod-morph"; #binding-cells = <0>;
                       bindings = <&kp F>, <&kp G>; mods = <(MOD_LSFT | MOD_RSFT)>; };
        GamVB: GamVB { compatible = "zmk,behavior-mod-morph"; #binding-cells = <0>;
                       bindings = <&kp V>, <&kp B>; mods = <(MOD_LSFT | MOD_RSFT)>; };
        GamEI: GamEI { compatible = "zmk,behavior-mod-morph"; #binding-cells = <0>;
                       bindings = <&kp E>, <&kp I>; mods = <(MOD_LSFT | MOD_RSFT)>; };
#endif
    };

// Every layer is one LAYOUT() call: 36 core keys, then the 10 optional slots.
// Boards that lack a slot drop it; nothing here needs an #ifdef.

#define L_BASE LAYOUT(                                                        \
    &kp B,       &kp L,            &kp D,        &HML LGUI W,  &kp Z,             \
    &kp SQT,     &HMR LGUI F,      &kp O,        &kp U,        &kp J,             \
    &lt RAISE N,   &HML LCTRL R,   &HML LALT T,  &lt NAV S,    &kp G,             \
    &kp Y,       &lt NAV H,        &HMR LALT A,  &HMR LCTRL E, &lt RAISE I,       \
    &kp Q,       &kp X,            &kp M,        &kp C,        &kp V,             \
    &kp K,       slashP,           KEY_DOT,      &kp MINUS,    &kp SLASH,         \
    &mo LOWER,   &ltl LOWER BSPC,  &kp LSHFT,    HYPEReturn,   MehSpace, &mo RAISE, \
    XXX,         XXX,              &kp TAB,      &kp ESC,                         \
    KEY_GAME,    &kp COMMA,        &kp C_MUTE,   &kp C_PP,     &none,    &none)

#define L_LOWER LAYOUT(                                                       \
    ___,         &kp AMPS,     &kp STAR,     ___,          ___,               \
    ___,         &kp N7,       &kp N8,       &kp N9,       &kp N0,            \
    &kp ESC,     &kp DLLR,     &kp PRCNT,    &kp CARET,    ___,               \
    ___,         &kp N4,       &kp N5,       &kp N6,       ___,               \
    ___,         &kp EXCL,     &kp AT,       &kp HASH,     ___,               \
    ___,         &kp N1,       &kp N2,       &kp N3,       ___,               \
    ___,         ___,          ___,          ___,          ___,      ___,     \
    ___,         ___,          ___,          ___,                             \
    ___,         ___,          ___,          ___,          ___,      ___)

#define L_RAISE LAYOUT(                                                       \
    ___,         ___,          ___,          ___,          ___,               \
    &kp F12,     &kp F7,       &kp F8,       &kp F9,       &kp TILDE,         \
    &kp ESC,     ___,          &kp MINUS,    &kp EQUAL,    &kp TILDE,         \
    &kp F11,     &kp F4,       &kp F5,       &kp F6,       &kp BSLH,          \
    ___,         ___,          &kp UNDER,    &kp PLUS,     &kp GRAVE,         \
    &kp F10,     &kp F1,       &kp F2,       &kp F3,       &kp PIPE,          \
    ___,         ___,          ___,          ___,          ___,      ___,     \
    ___,         ___,          ___,          &none,                           \
    ___,         &kp GRAVE,    ___,          ___,          ___,      ___)

#define L_NAV LAYOUT(                                                         \
    ___,         &kp LC(TAB),  &kp DEL,      &kp C_MUTE,   &bt BT_NXT,        \
    &trans,      &kp CMD(C),    ___,          &kp CMD(V),    ___,               \
    &kp ESC,     &kp TAB,      ___,          &kp C_VOL_UP, ___,               \
    &kp LEFT,    &kp DOWN,     &kp UP,       &kp RIGHT,     &kp CMD(EQUAL),     \
    ___,         ___,          ___,          &kp C_VOL_DN, &bt BT_CLR_ALL,    \
    ___,         &kp PG_DN,    &kp CAPS,     &kp PG_UP,    &kp CMD(MINUS),     \
    ___,         ___,          ___,          ___,          ___,      ___,     \
    ___,         ___,          ___,          ___,                             \
    ___,         ___,          ___,          ___,          ___,      ___)

// Summoned by holding LOWER and RAISE together, so it costs no key. Nearly all
// left hand: on the sweep, reaching RAISE uses the right index, and keeping the
// system keys on one hand means the same chord and the same keys on all seven.
// Everything else is XXX rather than transparent, so a stray press while the
// chord is held does nothing instead of typing a letter.
//
// The exception is the second bootloader, mirrored onto the right hand. It has
// to be: &bootloader resets the half the key is physically on, so one key can
// only ever put one half into bootloader mode, and the right half would
// otherwise still need the button on the board pressed by hand.
#define L_SYS LAYOUT(                                                         \
    &bt BT_SEL 0, &bt BT_SEL 1, &bt BT_SEL 2, &bt BT_SEL 3, &bt BT_CLR,       \
    XXX,          XXX,          XXX,          XXX,          XXX,              \
    XXX,          XXX,          XXX,          XXX,          XXX,              \
    XXX,          XXX,          XXX,          XXX,          XXX,              \
    &bootloader,  &sys_reset,   XXX,          &out OUT_TOG, XXX,              \
    XXX,          XXX,          XXX,          XXX,          &bootloader,      \
    XXX,         XXX,         XXX,         XXX,         XXX,         XXX,     \
    XXX,          XXX,          XXX,          XXX,                            \
    XXX,         XXX,         XXX,         XXX,         XXX,         XXX)

#ifdef HAS_GAMING
#define L_GAMING LAYOUT(                                                      \
    &kp TAB,     &kp Q,        &kp W,        &GamEI,       &GamRT,            \
    ___,         ___,          ___,          ___,          ___,               \
    &kp LCTL,    &kp A,        &kp S,        &kp D,        &GamFG,            \
    ___,         ___,          ___,          ___,          ___,               \
    &kp LALT,    &kp Z,        &kp X,        &kp C,        &GamVB,            \
    ___,         ___,          ___,          ___,          ___,               \
    ___,         &kp ENTER,    &kp SPACE,    ___,          ___,      ___,     \
    ___,         ___,          ___,          ___,                             \
    &tog GAMING, ___,          ___,          ___,          ___,      ___)
#endif

// A plain QWERTY layer, for a board that wants ordinary letter positions
// available without giving up the main layout. Homerow mods and the layer
// keys stay, so it behaves like the base layer with different letters on it.
#ifdef HAS_QWERTY
#define L_QWERTY LAYOUT(                                                      \
    &kp Q,       &kp W,        &kp E,        &HML LGUI R,  &kp T,             \
    &kp Y,       &HMR LGUI U,  &kp I,        &kp O,        &kp P,             \
    &lt RAISE A, &HML LCTRL S, &HML LALT D,  &lt NAV F,    &kp G,             \
    &kp H,       &lt NAV J,    &HMR LALT K,  &HMR LCTRL L, &lt RAISE SEMI,    \
    &kp Z,       &kp X,        &kp C,        &kp V,        &kp B,             \
    &kp N,       &kp M,        &kp COMMA,    &kp PERIOD,   &kp SLASH,         \
    &mo LOWER,   &kp BSPC,     &kp LSHFT,    HYPEReturn,   MehSpace,          \
    &mo RAISE,   XXX,          XXX,          &kp TAB,      &kp ESC,           \
    &tog QWERTY, &kp COMMA,    &kp C_MUTE,   &kp C_PP,     &kp LGUI,          \
    &kp RGUI)
#endif

    // Holding LOWER and RAISE at once brings up SYS. That is the only way in:
    // no key on any layer switches to it, which is what keeps it out of the way
    // until it is wanted.
    conditional_layers {
        compatible = "zmk,conditional-layers";
        sys { if-layers = <LOWER RAISE>; then-layer = <SYS>; };
    };

    keymap {
        compatible = "zmk,keymap";

        base_layer  { display-name = "Base";  bindings = <L_BASE>;
                      ENCODERS
        };
        lower_layer { display-name = "Lower"; bindings = <L_LOWER>;
                      ENCODERS
        };
        raise_layer { display-name = "Raise"; bindings = <L_RAISE>;
                      ENCODERS
        };
        nav_layer   { display-name = "Nav";   bindings = <L_NAV>;
                      ENCODERS
        };
        // Must sit here, before the optional layers: ZMK numbers layers by the
        // order they appear, and SYS is defined as 4.
        sys_layer   { display-name = "Sys";   bindings = <L_SYS>; };
#ifdef HAS_GAMING
        gaming_layer { display-name = "Gaming"; bindings = <L_GAMING>; };
#endif
#ifdef HAS_QWERTY
        qwerty_layer { display-name = "Qwerty"; bindings = <L_QWERTY>;
                       ENCODERS
        };
#endif
    };
};
